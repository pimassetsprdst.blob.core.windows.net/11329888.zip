Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bath-Spas_Novellini_DIVINA-O-Offset-Corner-Bathtub-165X98-R.ifc
Time: 2020-05-27T12:29:27
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, DIVINA O Offset Corner Bathtub 165X98 R/H Standard Built-in DI116594D
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DIVINA O Offset Corner Bathtub 165X98 R/H Standard Built-in DI116594D; SKU (BO_prodsku): DI116594D; ManufacturName (BO_Manufac): Novellini; BrandUrl (BO_brandurl): https://www.novellini.co.uk/; ProductFamily (BO_prodfam): DIVINA; ProductGroup (BO_prodgroup): DIVINA O; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 1650; Height (BO_height): 630; Depth (BO_depth): 980; Weight (BO_weight): 1; QR (BO_boqrurl): http://bimobject.com/novellini/product/DI116594D; ProductDataUrl (BO_prodaturl): bimobject.com/novellini/product/DI116594D; ProductUrl (BO_producturl): https://www.novellini.com/content/com/int/en/collections/baths/divina/divina-o.html; InstallationInstructions (BO_montins): https://www.novellini.com/content/dam/novellini-archive/Pdf_Montaggio/vasche/60711IST%20DIVINA%20O/60711IST_07%20DIVINA%20O.pdf; TechnicalDescription (BO_techcert): https://www.novellini.com/content/dam/novellini-archive/Pdf_Scheda/NOVELLINI/2019/int/DIVINAO-2019-INT.pdf; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=8qvZhDd2qu0; MaterialMain (BO_mainmat): Acrylic; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bath & Spas; BimObjectCategoryCode (BO_bocat_code): sanitary-bath-spas; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 30181507; Uniclass14Code (BO_uniclass_1_4_code): L7211; Uniclass14Description (BO_uniclass_1_4_desc): Baths; Uniclass20Code (BO_uniclass_2_0_code): PR-31-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathing Fittings; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_06_08; Uniclass2015Description (BO_uniclass2015_desc): Baths; NBSReference (BO_nbs_ref): 31-06; NBSReferenceDescription (BO_nbs_desc): Bathing Fittings; OmniClassCode (BO_omniclass_code): 23-31 15 00; OmniClassDescription (BO_omniclass_name): Bathtubs; MasterFormat2014Code (BO_masterformat2014_code): 22 41 19; MasterFormat2014Description (BO_masterformat2014_name): Residential Bathtubs; UniFormat2Code (BO_uniformat2_code): C1030; UniFormat2Description (BO_uniformat2_name): Fittings; RegionEurope (BO_europe): AT, BA, BE, BG, CH, CZ, DE, ES, FR, GB, GR, HR, HU, IT, LT, LU, ME, NL, NO, PL, RO, RU, SI, SK, UA
